## nemu/configs/tmp_defconfig
```kconfig
CONFIG_CC_DEBUG=y
# CONFIG_TRACE is not set
CONFIG_PMEM_MALLOC=y
CONFIG_DEVICE=y
```
